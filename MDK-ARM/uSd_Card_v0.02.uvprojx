# Keil uVision project uSd_Card_v0.02.uvprojx, settings and files
target uSd_Card_v0.02 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: uSd_Card_v0.02
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;      ../Drivers/STM32F7xx_HAL_Driver/Inc;      ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FatFs/src/drivers;      ../Middlewares/Third_Party/FatFs/src;      ../Drivers/CMSIS/Include;      ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;      ..\Drivers\BSP\STM32746G-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_tim.c stm32f7xx_hal_sd.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_spi.c stm32f7xx_hal_uart.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/User
    ../Src/: stm32f7xx_it.c fatfs.c main.c stm32f7xx_hal_msp.c bsp_driver_sd.c Imagenes.c
  group BSP/stm32f7_discovery
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/ft5336
    ../Drivers/BSP/Components/ft5336/: ft5336.c
software components: CMSIS:CORE 4.1.0
